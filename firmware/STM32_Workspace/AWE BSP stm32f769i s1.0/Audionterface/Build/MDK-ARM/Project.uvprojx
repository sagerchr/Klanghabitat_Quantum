# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_DISCOVERY_AUDIOWEAVER (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32F769i_Discovery +hex
  AfterMake: cscript -nologo elfprocess.js #K #L ..\..\Bin\@L_MDK_ARM.bin $L@L.disasm
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,USE_USB_HS,USE_IOEXPANDER,CORE_M7,DSPC_CORTEX_M,ARM_MATH_CM7,USE_FLASH_FILE_SYSTEM,__FPU_PRESENT,USE_GPIO
  c misc: --C99
  c include: ..\..\Lib\AWEInclude;..\..\Lib\AWEInclude\Modules;..\..\Source;..\..\Vendor\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\Vendor\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Vendor\Drivers\BSP\STM32F769I-Discovery;..\..\Vendor\Drivers\CMSIS\Include;..\..\Vendor\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Vendor\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: RAM 0xc0000000 size 0x10000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\STM32F769I_Custom.sct
  link misc: --diag_suppress=L6329 --pad=0xFF --userlibpath=..\..\Vendor\Drivers\CMSIS\Lib\ARM  --userlibpath=..\..\Lib\AWELibs\MDK_ARM --userlibpath=..\..\Lib\STLibs\MDK_ARM arm_cortexM7lfsp_math.lib CFramework.lib ModuleHelperLib.lib VectorLib.lib Standard.lib Q15_Demo_ASRCLib.lib BAM_32b_CM7_Keil.lib BIQ_32b_CM7_Keil.lib GAM_32b_CM7_Keil.lib GrEq_32b_CM7_Keil.lib HPV_HQ_32b_CM7_Keil.lib OMNI2_MC_32b_CM7_Keil.lib OMNI2_SW_32b_CM7_Keil.lib SDR_32b_CM7_Keil.lib SMR_32b_CM7_Keil.lib SVC_32b_CM7_Keil.lib STModules_Keil_M7.lib FlashFileSystem.lib
  group Drivers/STM32F7xx_HAL_Driver
    ../../Vendor/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_ll_usb.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2c.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2s.c stm32f7xx_hal_qspi.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dsi.c stm32f7xx_hal_ltdc_ex.c
  group Application/User
    ../../Source/: main.c Platform.c AudioDriver.c TuningDriver.c BoardSetup.c stm32f7xx_it.c ControlDriver.c USBDescriptors.c GPIO.c
  group Middlewares/STM32_USBD_Library/Core
    ../../Source/: usbd_desc.c usbd_ctlreq.c usbd_conf.c usbd_audio_if.c usbd_audio.c
    ../../Vendor/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c
  group Drivers/BSP/STM32F796I-DISCOVERY
    ../../Vendor/Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_qspi.c stm32f769i_discovery_sdram.c stm32f769i_discovery_audio.c
    ./: startup_stm32f769xx.s
    ../../Vendor/Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../Source/: wm8994_Modified.c
    ../../Vendor/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
software components: CMSIS:CORE 5.0.2
