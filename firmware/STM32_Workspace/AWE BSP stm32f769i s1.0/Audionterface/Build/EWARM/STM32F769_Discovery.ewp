# IAR project STM32F769_Discovery.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; CORE_M7; DSPC_CORTEX_M; ARM_MATH_CM7; USE_FLASH_FILE_SYSTEM; HID_INTERFACE; STM32F769xx; PROFILE_TIMES; EXTERNMODULETABLE; USE_GPIO; USE_USB_HS; USE_IOEXPANDER; DATA_IN_ExtSDRAM
  ICCARM.IExtraOptions: --diag_suppress Pa082
  ICCARM.CCIncludePath2: ..\..\Source; ..\..\Lib\AWEInclude; ..\..\Vendor\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\Vendor\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy; ..\..\Vendor\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Vendor\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\Vendor\Drivers\CMSIS\Include; ..\..\Vendor\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\Vendor\Drivers\BSP\STM32F769I-Discovery; ..\..\..\..\GIT_Sandbox\awe-mod-ext-st\Include; ..\..\Lib\AWEInclude\Modules
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Bin\STM32F769i_Discovery_EWARM.bin
  ILINK.IlinkOutputFile: STM32F769_Discovery.out
  ILINK.IlinkIcfFile: stm32f769x.icf
  ILINK.IlinkExtraOptions: --diag_suppress Lt009
  ILINK.IlinkAdditionalLibs: ..\..\Lib\AWELibs\EWARM\Standard.a; ..\..\Lib\AWELibs\EWARM\CFramework.a; ..\..\Lib\AWELibs\EWARM\ModuleHelperLib.a; ..\..\Lib\AWELibs\EWARM\VectorLib.a; ..\..\Lib\AWELibs\EWARM\Q15_Demo_ASRCLib.a; ..\..\Vendor\Drivers\CMSIS\Lib\ARM\iar_cortexM7lf_math.a; ..\..\Lib\STLibs\EWARM\STModules_IAR_M7.a; ..\..\Lib\STLibs\EWARM\SDR_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\BAM_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\BIQ_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\GAM_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\GrEq_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\HPV_HQ_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\OMNI2_SW_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\SMR_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\SVC_32b_CM7_IAR.a; ..\..\Lib\STLibs\EWARM\OMNI2_MC_32b_CM7_IAR.a; ..\..\Lib\AWELibs\EWARM\FlashFileSystem.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f769xx.s
  group Application/User
    ../../Source/: AudioDriver.c BoardSetup.c ControlDriver.c GPIO.c main.c Platform.c stm32f7xx_hal_msp.c stm32f7xx_it.c TuningDriver.c USBDescriptors.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../Vendor/Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c stm32f769i_discovery_audio.c stm32f769i_discovery_lcd.c stm32f769i_discovery_qspi.c stm32f769i_discovery_sdram.c
    ../../Vendor/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
    ../../Source/: wm8994_Modified.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../Vendor/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../../Source/: usbd_audio.c usbd_audio_if.c usbd_conf.c usbd_ctlreq.c usbd_desc.c
    ../../Vendor/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c
