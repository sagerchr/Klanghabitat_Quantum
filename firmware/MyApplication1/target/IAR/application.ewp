# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ST; STM32F469xx; USE_FLOATING_POINT; USE_OS_SYSTICK; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\generated\images\include; ..\..\generated\fonts\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\platform\os; ..\..\gui\include; ..\..\target\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\cortex-m; ..\bsp\include\platform\cortex-m\CMSIS; ..\bsp\include\platform\hal\mcu\stm32f4cube; ..\bsp\include\platform\hal\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\bsp\include\platform\hal\mcu\stm32f4cube\CMSIS; ..\bsp\include; ..\bsp\include\bsp; ..\bsp\source\vendor\STM32469I-Discovery; ..\os\FreeRTOS7.6.0\Source\include; ..\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkExtraOptions: --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKc9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKc8_VA_LIST; --redirect _ZN8touchgfx7Unicode9vsnprintfEPttPKt9__va_list=_ZN8touchgfx7Unicode9vsnprintfEPttPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthRTLEhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthRTLEhPKt8_VA_LIST
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Roboto_Black_58_4bpp.cpp Font_Roboto_Medium_20_4bpp.cpp Font_Roboto_Regular_17_4bpp.cpp Font_Roboto_Regular_50_4bpp.cpp FontGetters.cpp Kerning_Roboto_Black_58_4bpp.cpp Kerning_Roboto_Medium_20_4bpp.cpp Kerning_Roboto_Regular_17_4bpp.cpp Kerning_Roboto_Regular_50_4bpp.cpp Table_Roboto_Black_58_4bpp.cpp Table_Roboto_Medium_20_4bpp.cpp Table_Roboto_Regular_17_4bpp.cpp Table_Roboto_Regular_50_4bpp.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/containers
    ../../generated/gui_generated/src/containers/: imageContainerBase.cpp textCenterContainerBase.cpp textContainerBase.cpp
  group Application/generated/gui_generated/screen1_screen
    ../../generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: background.cpp BitmapDatabase.cpp button.cpp button_pressed.cpp mask.cpp radio_button_selected.cpp radio_button_selected_pressed.cpp radio_button_unselected.cpp radio_button_unselected_pressed.cpp scroll_wheel_frame.cpp scrollBg.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: blue_backgrounds_main_bg_texture_800x480px.cpp
  group Application/generated/images/Icons
    ../../generated/images/src/Icons/: alert.cpp calendar.cpp document.cpp email.cpp folder.cpp home.cpp inbox.cpp map.cpp movie.cpp news.cpp sound.cpp tools.cpp trash.cpp user.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/containers
    ../../gui/src/containers/: imageContainer.cpp textCenterContainer.cpp textContainer.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/screen1_screen
    ../../gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group Application/main
    ../: main.cpp
  group CubeF4/Board
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
    ../bsp/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
  group CubeF4/MCU
    ../bsp/source/platform/hal/mcu/stm32f4cube/IAR/: startup_stm32f469xx.s
    ../bsp/source/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ../bsp/source/platform/hal/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: Buttons.cpp KeySampler.cpp OTM8009TouchController.cpp
  group TouchGFXPort/MCU
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
